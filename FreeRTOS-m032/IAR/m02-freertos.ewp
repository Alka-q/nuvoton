# IAR project m02-freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M031AE series Nuvoton M031AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\Library\Device\Nuvoton\M031\Include; $PROJ_DIR$..\..\Library\StdDriver\inc; ..\; ..\FreeRTOS-lib\Source\include; ..\FreeRTOS-lib\Source\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\Library\Device\Nuvoton\M031\Include; $PROJ_DIR$..\..\Library\StdDriver\inc; ..\FreeRTOS-lib\Source\include; $PROJ_DIR$..\..\
  OBJCOPY.OOCOutputFile: gsm-m.hex
  ILINK.IlinkOutputFile: gsm-m.out
  ILINK.IlinkIcfFile: freertos.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../Library/Device/Nuvoton/M031/Source/IAR/: startup_M031Series.s
    ../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
  group FreeRTOS-lib
    ../FreeRTOS-lib/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS-lib/Source/portable/MemMang/: heap_2.c
    ../FreeRTOS-lib/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group Library
    ../Library/StdDriver/src/: acmp.c adc.c bpwm.c clk.c crc.c ebi.c fmc.c gpio.c i2c.c pdma.c pwm.c qspi.c retarget.c rtc.c spi.c sys.c timer.c uart.c usbd.c usci_i2c.c usci_spi.c usci_uart.c wdt.c wwdt.c
  group User
    ../User/: main.c
