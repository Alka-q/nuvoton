<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\m02-freertos.ewp</path>
    </project>
    <batchBuild />
</workspace>
